# Keil uVision project GD32H737_Base.uvprojx, settings and files
target GD32H737 (6160000::V6.16::ARMCLANG)
  device: GD32H737VM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GD32H737_Base
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\GD32H7_study\GD32H7xx_Demo_Suites_V2.1.0\GD32H7xx_Firmware_Library\CMSIS\GD\GD32H7xx\Include;..\GD32H7_study\GD32H7xx_Demo_Suites_V2.1.0\GD32H7xx_Firmware_Library\GD32H7xx_standard_peripheral\Include;..\h737vmt6_AI1.0;..\GD32H7_study\GD32_H7_AI\1.0\inc;..\GD32H7_study\GD32_H7_AI\1.0;..\GD32H7_study\GD32_H7_AI\1.0\inc\operators\cmsis_nn;..\GD32H7_study\GD32_H7_AI\1.0\inc\operators\third_party
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  group CMSIS
    ../GD32H7_study/GD32H7xx_Demo_Suites_V2.1.0/GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
    ../GD32H7_study/GD32H7xx_Demo_Suites_V2.1.0/GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group StdPeriph_Driver
    ../GD32H7_study/GD32H7xx_Demo_Suites_V2.1.0/GD32H7xx_Firmware_Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_gpio.c gd32h7xx_usart.c gd32h7xx_rcu.c gd32h7xx_pmu.c gd32h7xx_misc.c gd32h7xx_dma.c
  group User
    ./: main.c gd32h7xx_libopt.h gd32h7xx_it.c
  group AI_Module
    ../GD32H7_study/GD32_H7_AI/1.0/: nn_model_configure.c GD_LIB_CM7_v212.lib systick.c
software components: CMSIS:CORE 5.4.0
